# Keil uVision project demo.uvprojx, settings and files
target demo (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\RTE\Device\STM32F407ZE;.\RTE;.\SYSTEM\sys;.\SYSTEM\delay;.\HARDWARE\BEEP;.\HARDWARE\OLED;.\HARDWARE\DHT11;.\HARDWARE\SR04;.\HARDWARE\FLASH;.\HARDWARE\W25Q128;.\HARDWARE\MFRC522
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group user
    ./: main.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/delay/: delay.c
    ./HARDWARE/BEEP/: beep.c
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/DHT11/: dht11.c
    ./HARDWARE/SR04/: sr04.c
    ./HARDWARE/FLASH/: flash.c
    ./HARDWARE/W25Q128/: w25q128.c
    ./HARDWARE/MFRC522/: MFRC522.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.3.1, Device:StdPeriph Drivers:ADC 1.3.0, Device:StdPeriph Drivers:EXTI 1.3.0, Device:StdPeriph Drivers:Flash 1.3.0, Device:StdPeriph Drivers:Framework 1.3.1, Device:StdPeriph Drivers:GPIO 1.3.0, Device:StdPeriph Drivers:IWDG 1.3.0, Device:StdPeriph Drivers:PWR 1.3.0, Device:StdPeriph Drivers:RCC 1.3.0, Device:StdPeriph Drivers:RTC 1.3.0, Device:StdPeriph Drivers:SPI 1.3.0, Device:StdPeriph Drivers:SYSCFG 1.3.0, Device:StdPeriph Drivers:TIM 1.3.0, Device:StdPeriph Drivers:USART 1.3.0
